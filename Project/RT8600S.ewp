# IAR project RT8600S.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG280F128 EnergyMicro EFM32LG280F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32LG280F128
  ICCARM.CCIncludePath2: ..\Include\; ..\BL\; ..\emlib\inc\; ..\CMSIS\CoreSupport\; ..\CMSIS\DeviceSupport\EFM32LG\Include\; ..\CMSIS\DeviceSupport\EFM32LG\Source\; ..\CMSIS\DeviceSupport\EFM32LG\Source\IAR\; ..\Application\src\; ..\Application\inc; ..\Application\Massage
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RT6923.bin
  ILINK.IlinkOutputFile: RT8600_New.out
  ILINK.IlinkIcfFile: RT6923.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ; Include\; BL\; emlib\inc\; CMSIS\CoreSupport\; CMSIS\DeviceSupport\EFM32LG\Include\; CMSIS\DeviceSupport\EFM32LG\Source\; CMSIS\DeviceSupport\EFM32LG\Source\IAR\
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: RT8600S.bin
  ILINK.IlinkOutputFile: RT8600S.out
  ILINK.IlinkIcfFile: E:\RT8700B_项目\RT8700B_Main_RT000_ALL_V2.04_2016053011个自动程序\源代码\RT8600S.icf
  group CMSIS
    ../CMSIS/DeviceSupport/EFM32LG/Source/IAR/: startup_efm32lg.s
    ../CMSIS/DeviceSupport/EFM32LG/Source/: system_efm32lg.c
  group EFM32lib
    ../emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group Local
    ../Application/src/: main.c system.c
  group Peripheral
    ../Application/src/: ADC_scan.c ADC_Temperature.c AxisMotor.c BackPad.c BlueTooth.c DMA_Ctrl.c Flex_Uart .c HandUart_New.c IndicateLED.c Input.c KneadMotor.c KnockMotor_8840.c LED_RGB.c LegKnead_Uart.c LegMotor.c memory.c Mp3Ctrl.c NetCloud.c Power.c problem.c Rock.c Roller_Uart.c signalUart_new.c SingleLine.c SlideMotor.c UartLeg.c Valve.c VoiceUart.c WaistHot.c WalkMotor.c xmodem.c
  group Software
    ../Application/src/: Data_Cul.c MassageStatus.c Timer.c
